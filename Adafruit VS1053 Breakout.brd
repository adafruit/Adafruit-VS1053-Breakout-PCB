# Repository adafruit/Adafruit-VS1053-Breakout-PCB

File README.md:

## Adafruit VS1053 Music Breakout PCB
<a href="http://www.adafruit.com/products/1381"><br/>
Click here to purchase one from the Adafruit shop</a>

This breakout board is the ultimate companion for the VLSI VS1053B DSP codec chip. The VS1053 can decode a wide variety of audio formats such as MP3, AAC, Ogg Vorbis, WMA, MIDI, FLAC, WAV (PCM and ADPCM). It can also be used to record audio in both PCM (WAV) and compressed Ogg Vorbis. You can do all sorts of stuff with the audio as well such as adjusting bass, treble, and volume digitally. There is also 8 GPIO pins that can be used for stuff like lighting up small LEDs or reading buttons.

All this functionality is implemented in a light-weight SPI interface so nearly any microcontroller can play audio from an SD card. There's also a special MIDI mode that you can boot the chip into that will read 'classic' 31250Kbaud MIDI data on a UART pin and act like a synth/drum machine - there are dozens of built-in drum and sample effects! But the chip is a pain to solder, and needs a lot of extras. That's why we spun up the best breakout, perfect for use with an Arduino but also good for other microcontrollers that just don't have the computational power to decode MP3s.

This is the PCB for the Adafruit VS1053 (MP3/MIDI/WAV/Ogg...) Breakout board. The format is EagleCAD schematic and board layout
- https://www.adafruit.com/product/1381

### License

Adafruit invests time and resources providing this open source design, please support Adafruit and open-source hardware by purchasing products from [Adafruit](https://www.adafruit.com)!

All text above must be included in any redistribution

Designed by Limor Fried/Ladyada for Adafruit Industries.
Creative Commons Attribution/Share-Alike, all text above must be included in any redistribution. 
See license.txt for additional information.

## EAGLE design Adafruit VS1053 Breakout.brd

Parts:
C1, C2: 220uF; PANASONIC_C
C4, C5: 10pF; _0805MP
C6, C7, C19, C20: 10µF; _0805MP
C8, C26: 0.1µF; _0805MP
C21, C22: 10nF (0.01uF); _0805MP
CN1: 2908-05WB-M6; MICROSD
D1: 1N4148; SOD-323
FB1, FB2: FERITTE; _0805MP
FID1, FID2: FIDUCIAL""; FIDUCIAL_1MM
JP2, JP3: HEADER-1X16ROUND; 1X16_ROUND
R1: 1M; _0805MP
R2: 100K; _0805MP
R3, R4: 20; _0805MP
R6, R7: 100; _0805MP
R8, R9, R16: 100K; RESPACK_4X0603
R10: 10K; 0805-NO
U1: VS1053B; LQFP48
U2: AP7312-1833W6-7; SOT23-6
U3: 74HC4050D; SOIC16
U$50, U$51, U$52, U$53: MOUNTINGHOLE3.0THIN; MOUNTINGHOLE_3.0_PLATEDTHIN
Y1: ABM8G-12.288MHZ-4Y-T3; CRYSTAL_3.2X2.5

Connections:
1.8V: C6.1, U1.5 (CVDD), U1.7 (CVDD), U1.24 (CVDD), U1.31 (CVDD), U2.6 (VOUT1)
3.3V: C7.1, C19.1, CN1.4 (SD_VDD), FB1.1, JP2.8, JP3.5, R9.5 (2), R9.6 (2), R9.7 (2), R10.2, U1.6 (IOVDD), U1.14 (IOVDD), U1.19 (IOVDD), U1.32 (XTEST), U2.1 (VOUT2), U3.1 (VCC)
AGND: C8.2, C21.2, C22.2, FB2.2, JP2.3, JP2.4, JP3.4, U1.37 (AGND), U1.40 (AGND), U1.41 (AGND), U1.47 (AGND)
AVDD: C8.1, FB1.2, R2.1, U1.38 (AVDD), U1.43 (AVDD), U1.45 (AVDD)
CLKOUT: U1.15 (VCO)
CS_3V: U1.23 (XCS), U3.10 (4Y)
CS_5V: JP2.14, R9.2 (1), U3.9 (4A)
DREQ: JP2.6, U1.8 (DREQ)
GND: C4.2, C5.2, C6.2, C7.2, C19.2, C20.2, C26.2, CN1.6 (GND), CN1.MT1 (GND), CN1.MT2 (GND), FB2.1, JP2.5, JP2.9, R8.5 (2), R8.6 (2), R8.7 (2), R8.8 (2), R9.8 (2), R16.5 (2), R16.6 (2), R16.7 (2), R16.8 (2), U1.4 (DGND), U1.16 (DGND), U1.20 (DGND), U1.21 (DGND), U1.22 (DGND), U1.35 (GND), U2.2 (GND), U3.8 (GND)
GPIO0: JP3.6, R16.1, U1.33 (GPIO0)
GPIO1: JP3.7, R16.2 (1), U1.34 (GPIO1)
GPIO2: JP3.8, R16.3 (1), U1.9 (GPIO2/DCLK)
GPIO3: JP3.9, R16.4 (1), U1.10 (GPIO3/SDATA)
GPIO4: JP3.10, R8.1, U1.36 (GPIO4/I2S_LROUT)
GPIO5: JP3.11, R8.2 (1), U1.25 (GPIO5/I2S_MCLK)
GPIO6: JP3.12, R8.3 (1), U1.11 (GPIO6/I2S_SCLK)
GPIO7: JP3.13, R8.4 (1), U1.12 (GPIO7/I2S_SDATA)
LEFT: R3.1, R7.2, U1.46 (LEFT)
LEFT_FILTERED: C2.+, R7.1
LINE2: JP3.1, U1.48 (LINE2)
L_OUT: C2.-, JP2.2
MIC_N: JP3.3, U1.2 (MIC_N)
MIC_P: JP3.2, U1.1 (MIC_P/LINEIN)
MISO: CN1.7 (DATA_OUT), JP2.10, U1.30 (SO)
MOSI_3V: CN1.3 (DATA_IN), U1.29 (SI), U3.4 (2Y)
MOSI_5V: JP2.11, U3.5 (2A)
unnamed: C5.1, R1.1, U1.17 (XTALOUT), Y1.1
unnamed: C4.1, R1.2, U1.18 (XTALIN), Y1.2
unnamed: C21.1, R3.2
unnamed: C22.1, R4.2
RIGHT: R4.1, R6.2, U1.39 (RIGHT)
RIGHT_FILTERED: C1.+, R6.1
RST_3V: C26.1, R2.2, U1.3 (XRESET), U3.2 (1Y)
RST_5V: JP2.13, R9.1, U3.3 (1A)
RX: D1.A, R10.1, U1.26 (RX)
RX_5V: D1.C, JP3.15
R_OUT: C1.-, JP2.1
SCLK_3V: CN1.5 (SCLK), U1.28 (SCLK), U3.6 (3Y)
SCLK_5V: JP2.12, U3.7 (3A)
SDCS_3V: CN1.2 (CS), U3.12 (5Y)
SDCS_5V: JP2.15, R9.3 (1), U3.11 (5A)
SD_DETECT: CN1.CD1 (CARD_DETECT), JP3.16
TX: JP3.14, U1.27 (TX)
VIN: C20.1, JP2.7, U2.3 (EN2), U2.4 (EN1), U2.5 (VIN)
XDCS_3V: U1.13 (XDCS/BSYNC), U3.15 (6Y)
XDCS_5V: JP2.16, R9.4 (1), U3.14 (6A)

Notes on the sheet:
Analog Supply Filtering
C4,C5 = 2*CL - 2*Cstray
C4,C5 = 2*10pF - 2*5pF
C4,C5 = 10pF
VS1053 oscillator requires
1M resistor for DC bias
Set RX to IOVDD if not used
DREQ high = at least 32 bytes
Not buffered (3V3)!
Power Supply/Decoupling
transients during power up which can
damage the earphones and causes
'clicks' ... this setup should minimize
that. See section 8 of
http://www.vlsi.fi/uploads/media/vs10XXan.pdf
Enabling the IC too soon can cause
free in FIFO
Disable SPI boot with GPIO0 low
1 / (2*π*f*Xc)
16 ohm load at 20Hz cuttoff
1 / (6.2832*20hz*16)
C1, C2 =
= 497µF
32 ohm load at 20Hz cuttoff
1 / (6.2832*20hz*32)
= 249µF
Caps: UKA0J471MPD1TD

Board: 2 copper layers, 27.6 x 57.7 mm, 40 parts (1 on the bottom side), 45 nets.

Other parts of the board:
U$31: ADAFRUIT_3.5MM
U$55: ADAFRUIT_TEXT_20MM

## Commit log

2014-05-19 monnnday!
2016-06-14 nicer readme
